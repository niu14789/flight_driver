# Keil uVision project driver.uvprojx, settings and files
target driver (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F303RC GigaDevice
  pack: GigaDevice.GD32F30x_DFP.1.0.3
  cpu: IRAM(0x20000000,0x0C000) IROM(0x08000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: driver +hex
  AfterMake: drone_output.bat
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\Lib\CMSIS\GD\GD32F30x\Include;..\Lib\CMSIS;..\Lib\GD32F30x_standard_peripheral\Include;..\Utilities;..\;C:\Keil_v5\ARM\Pack\ARM\CMSIS\4.2.0\CMSIS\Include;..\sensor\Dps310;..\sensor\Gps;..\sensor\ICM20600;..\sensor\Calibration;..\sensor\ST480;..\driver\SPI;..\driver\InternalFlash;..\driver\Parameter;..\driver\Usart;..\user\TEST;..\link;..\driver\PWM;..\driver\led;..\driver\adc;..\driver\sbus;..\Lib\GD32F30x_usbd_driver\Include;..\driver\CdcAcm;..\driver\I2C;..\common\file_system;..\driver\icm;..\driver\common;..\user
  library: MicroLIB
  memory RVCT4: ROM 0x8010000 size 0x2000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --keep __FS_*;--keep __FS_SHELL_*
  group basic
    ../Lib/CMSIS/GD/GD32F30x/Source/ARM/: startup_gd32f30x_xd.s
    ../Lib/CMSIS/GD/GD32F30x/Source/: system_gd32f30x.c
    ../user/: gd32f30x_it.c main.c
  group gd32lib
    ../Lib/GD32F30x_standard_peripheral/Source/: gd32f30x_timer.c gd32f30x_rcu.c gd32f30x_misc.c
  group fs
    ../common/file_system/: f_open.c f_shell.c fs_inode.c
  group runtime
    ../common/file_system/: fs_runs.c runtime.c
software components: CMSIS:CORE 5.1.2
